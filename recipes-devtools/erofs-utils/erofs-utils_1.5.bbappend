FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRCREV = "b9ebaad0af653e9a85752193c2b5f3f04791068d"
SRC_URI = "git://git.kernel.org/pub/scm/linux/kernel/git/xiang/erofs-utils.git;branch=dev"
