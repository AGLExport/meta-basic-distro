PACKAGECONFIG = "\
    wayland-client \
    wayland-server \
    dmabuf-client-buffer \
    examples \
"

PACKAGECONFIG:class-native = ""
PACKAGECONFIG:class-nativesdk = ""

