PACKAGECONFIG_append = " examples "

