PACKAGECONFIG_append = " examples "
