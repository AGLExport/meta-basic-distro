PACKAGECONFIG:append = " examples "
PACKAGECONFIG:remove:class-native = " examples"
PACKAGECONFIG:remove:class-nativesdk = " examples"
