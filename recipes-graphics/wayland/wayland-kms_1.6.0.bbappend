SRCREV = "a588cecb78acf176ee94d7dfa50a553a1f901efa"
SRC_URI = "git://github.com/thayama/wayland-kms.git;branch=master"
