SUMMARY = "Standard library set"
LICENSE = "CLOSED & MIT"

inherit packagegroup

PACKAGES = " \
    packagegroup-standard-library-set \
"

PR = "r0"

RDEPENDS_packagegroup-standard-library-set = " \
    glib-2.0 \
"
